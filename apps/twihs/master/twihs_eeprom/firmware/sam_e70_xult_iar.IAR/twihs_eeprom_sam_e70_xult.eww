<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\twihs_eeprom_sam_e70_xult.ewp</path>
    </project>
</workspace>
