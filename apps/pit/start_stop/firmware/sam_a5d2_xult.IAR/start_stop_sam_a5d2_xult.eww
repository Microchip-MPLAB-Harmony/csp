<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\start_stop_sam_a5d2_xult.ewp</path>
    </project>
    <batchBuild />
</workspace>
