<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pit_led_toggle_polling_sam_9x60_ek.ewp</path>
    </project>
    <batchBuild />
</workspace>
