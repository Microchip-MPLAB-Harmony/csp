<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\led_toggle_polling_sam_a5d2_xult.ewp</path>
    </project>
</workspace>
