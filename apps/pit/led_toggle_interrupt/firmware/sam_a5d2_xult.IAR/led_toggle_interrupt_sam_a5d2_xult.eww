<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\led_toggle_interrupt_sam_a5d2_xult.ewp</path>
    </project>
    <batchBuild />
</workspace>
