<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\shdwc_piobu0_wakeup_sam_a5d2_xult.ewp</path>
    </project>
</workspace>
