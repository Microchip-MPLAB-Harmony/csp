# IAR project clock_low_power_sam_a5d2_xult_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ../../firmware/src; ../../firmware/src/config/sam_a5d2_xult_iar; ../../firmware/src/packs/ATSAMA5D27_DFP; ../../firmware/src/packs/CMSIS/CMSIS/Core_A/Include; ../../firmware/src/packs/CMSIS; ../../firmware/src/arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: clock_low_power_sam_a5d2_xult_iar.out
  ILINK.IlinkIcfFile: ../../firmware/src/config/sam_a5d2_xult_iar/ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xult_iar/: sam_a5d2_xult_iar.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult_iar/: definitions.h device_cache.h toolchain_specifics.h
    ../src/config/sam_a5d2_xult_iar/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult_iar/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult_iar/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult_iar/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult_iar/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xult_iar/peripheral/pit/: plib_pit.h
    ../src/config/sam_a5d2_xult_iar/peripheral/rtc/: plib_rtc.h plib_rtc_common.h
    ../src/config/sam_a5d2_xult_iar/peripheral/uart/: plib_uart1.h plib_uart_common.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group IAR Project Connection File/Source Files
    ../src/config/sam_a5d2_xult_iar/: cstartup.s exceptions.c fault_handlers.c initialization.c interrupts.c
    ../src/config/sam_a5d2_xult_iar/stdio/: iar_monitor.c
    ../src/: main.c
    ../src/config/sam_a5d2_xult_iar/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult_iar/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult_iar/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult_iar/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult_iar/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult_iar/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xult_iar/peripheral/rtc/: plib_rtc.c
    ../src/config/sam_a5d2_xult_iar/peripheral/uart/: plib_uart1.c
