<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\clock_low_power_sam_a5d2_xult_iar.ewp</path>
    </project>
</workspace>
