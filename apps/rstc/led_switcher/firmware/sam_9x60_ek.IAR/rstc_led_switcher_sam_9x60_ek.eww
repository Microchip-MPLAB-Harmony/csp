<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rstc_led_switcher_sam_9x60_ek.ewp</path>
    </project>
    <batchBuild />
</workspace>
