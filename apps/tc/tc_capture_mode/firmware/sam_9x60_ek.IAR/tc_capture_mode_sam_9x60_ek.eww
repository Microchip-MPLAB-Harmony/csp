<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\tc_capture_mode_sam_9x60_ek.ewp</path>
    </project>
</workspace>
