# Keil uVision project usart_echo_interrupt_sam_c21n_xpro_keil.uvprojx, settings and files
target sam_c21n_xpro_keil (6130001::V6.13.1::.\ARMCLANG)
  device: ATSAMC21N18A Microchip
  pack: Keil.SAM-C_DFP.1.4.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sam_c21n_xpro_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_c21n_xpro_keil;..\src\packs\ATSAMC21N18A_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\src\config\sam_c21n_xpro_keil\sam_c21n_xpro_keil.sct
  group Harmony3
    ../src/config/sam_c21n_xpro_keil/peripheral/nvmctrl/: plib_nvmctrl.h plib_nvmctrl.c
    ../src/config/sam_c21n_xpro_keil/: device_cache.h toolchain_specifics.h definitions.h initialization.c interrupts.c exceptions.c startup_keil.c
    ../src/config/sam_c21n_xpro_keil/peripheral/port/: plib_port.h plib_port.c
    ../src/config/sam_c21n_xpro_keil/peripheral/clock/: plib_clock.h plib_clock.c
    ../src/config/sam_c21n_xpro_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/packs/ATSAMC21N18A_DFP/: device.h atsamc21n18a.h
    ../src/packs/ATSAMC21N18A_DFP/component/: ac.h adc.h can.h ccl.h dac.h divas.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h hmatrixb.h mclk.h mtb.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pm.h port.h ptc.h rstc.h rtc.h sdadc.h sercom.h supc.h tc.h tcc.h tsens.h wdt.h
    ../src/packs/ATSAMC21N18A_DFP/pio/: samc21n18a.h
    ../src/config/sam_c21n_xpro_keil/peripheral/sercom/usart/: plib_sercom4_usart.h plib_sercom_usart_common.h plib_sercom4_usart.c
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm0plus.h mpu_armv7.h
    ../src/: main.c
    ../src/config/sam_c21n_xpro_keil/stdio/: keil_monitor.c
