<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\usart_echo_interrupt_sam_e54_xpro.ewp</path>
    </project>
    <batchBuild />
</workspace>
