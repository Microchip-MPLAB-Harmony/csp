# Keil uVision project usart_echo_interrupt_sam_e54_xpro_keil.uvprojx, settings and files
target sam_e54_xpro_keil (6130001::V6.13.1::.\ARMCLANG)
  device: ATSAME54P20A Microchip
  pack: Atmel.SAME54_DFP.1.1.134
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sam_e54_xpro_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_e54_xpro_keil;..\src\packs\ATSAME54P20A_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\src\config\sam_e54_xpro_keil\sam_e54_xpro_keil.sct
  group Harmony3
    ../src/config/sam_e54_xpro_keil/peripheral/nvmctrl/: plib_nvmctrl.h plib_nvmctrl.c
    ../src/config/sam_e54_xpro_keil/peripheral/sercom/usart/: plib_sercom2_usart.h plib_sercom_usart_common.h plib_sercom2_usart.c
    ../src/config/sam_e54_xpro_keil/: device_cache.h toolchain_specifics.h definitions.h initialization.c interrupts.c exceptions.c startup_keil.c
    ../src/config/sam_e54_xpro_keil/peripheral/port/: plib_port.h plib_port.c
    ../src/config/sam_e54_xpro_keil/peripheral/clock/: plib_clock.h plib_clock.c
    ../src/config/sam_e54_xpro_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/config/sam_e54_xpro_keil/peripheral/cmcc/: plib_cmcc.h plib_cmcc.c
    ../src/packs/ATSAME54P20A_DFP/: device.h atsame54p20a.h
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm4.h mpu_armv7.h
    ../src/: main_e54.c
    ../src/config/sam_e54_xpro_keil/stdio/: keil_monitor.c
