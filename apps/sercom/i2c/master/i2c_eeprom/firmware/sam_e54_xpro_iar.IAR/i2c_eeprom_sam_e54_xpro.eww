<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\i2c_eeprom_sam_e54_xpro.ewp</path>
    </project>
    <batchBuild />
</workspace>
