# IAR project i2c_eeprom_sam_e54_xpro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_e54_xpro_iar; ..\..\firmware\src\packs\ATSAME54P20A_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: i2c_eeprom_sam_e54_xpro.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_e54_xpro_iar/: sam_e54_xpro_iar.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
    ../src/packs/ATSAME54P20A_DFP/: atsame54p20a.h device.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
    ../src/config/sam_e54_xpro_iar/: definitions.h device_cache.h toolchain_specifics.h
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.h
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.h
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.h
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.h
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.h
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/i2c_master/: plib_sercom7_i2c_master.h plib_sercom_i2c_master_common.h
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
  group IAR Project Connection File/Source Files
    ../src/config/sam_e54_xpro_iar/: exceptions.c initialization.c interrupts.c startup_iar.c
    ../src/config/sam_e54_xpro_iar/stdio/: iar_monitor.c
    ../src/: main_e54.c
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.c
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.c
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.c
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.c
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.c
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/i2c_master/: plib_sercom7_i2c_master.c
