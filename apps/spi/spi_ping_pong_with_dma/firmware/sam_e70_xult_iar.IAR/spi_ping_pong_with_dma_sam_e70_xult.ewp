# IAR project spi_ping_pong_with_dma_sam_e70_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_e70_xult_iar; ..\..\firmware\src\packs\ATSAME70Q21B_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: spi_ping_pong_with_dma_sam_e70_xult.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_e70_xult_iar/: sam_e70_xult_iar.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
    ../src/packs/ATSAME70Q21B_DFP/: atsame70q21b.h device.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
    ../src/config/sam_e70_xult_iar/: definitions.h device_cache.h toolchain_specifics.h
    ../src/config/sam_e70_xult_iar/peripheral/clk/: plib_clk.h
    ../src/config/sam_e70_xult_iar/peripheral/efc/: plib_efc.h
    ../src/config/sam_e70_xult_iar/peripheral/nvic/: plib_nvic.h
    ../src/config/sam_e70_xult_iar/peripheral/pio/: plib_pio.h
    ../src/config/sam_e70_xult_iar/peripheral/spi/: plib_spi0.h plib_spi_common.h
    ../src/config/sam_e70_xult_iar/peripheral/xdmac/: plib_xdmac.h plib_xdmac_common.h
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
  group IAR Project Connection File/Source Files
    ../src/config/sam_e70_xult_iar/: exceptions.c initialization.c interrupts.c startup_iar.c
    ../src/config/sam_e70_xult_iar/stdio/: iar_monitor.c
    ../src/: main.c
    ../src/config/sam_e70_xult_iar/peripheral/clk/: plib_clk.c
    ../src/config/sam_e70_xult_iar/peripheral/efc/: plib_efc.c
    ../src/config/sam_e70_xult_iar/peripheral/nvic/: plib_nvic.c
    ../src/config/sam_e70_xult_iar/peripheral/pio/: plib_pio.c
    ../src/config/sam_e70_xult_iar/peripheral/spi/: plib_spi0.c
    ../src/config/sam_e70_xult_iar/peripheral/xdmac/: plib_xdmac.c
