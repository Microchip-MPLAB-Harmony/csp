<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\xdmac_memory_transfer_sam_a5d2_xult.ewp</path>
    </project>
</workspace>
