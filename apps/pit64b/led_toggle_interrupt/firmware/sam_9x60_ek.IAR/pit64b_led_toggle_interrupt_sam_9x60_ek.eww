<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\pit64b_led_toggle_interrupt_sam_9x60_ek.ewp</path>
    </project>
</workspace>
