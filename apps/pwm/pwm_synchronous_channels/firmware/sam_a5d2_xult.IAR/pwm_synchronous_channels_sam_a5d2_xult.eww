<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwm_synchronous_channels_sam_a5d2_xult.ewp</path>
    </project>
    <batchBuild />
</workspace>
