<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_user_sequence_sam_a5d2_xult.ewp</path>
    </project>
    <batchBuild />
</workspace>
